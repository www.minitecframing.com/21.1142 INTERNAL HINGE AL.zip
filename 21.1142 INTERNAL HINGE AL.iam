# Autodesk Inventor assembly: 21.1142 INTERNAL HINGE AL
## iProperties
Created: 2007-01
Part Number: 21.1142 INTERNAL HINGE AL
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
